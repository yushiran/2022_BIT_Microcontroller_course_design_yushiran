# Keil uVision project game.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: game +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: game.c display_drive.h button_drive.h Tetris.h Tetris_define.h
